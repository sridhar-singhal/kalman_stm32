# Keil uVision project stm32F3_based.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F303C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: binary +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.cpp
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:STM32Cube HAL:COMMON 1.11.2, Device:STM32Cube HAL:CORTEX 1.11.2, Device:STM32Cube HAL:FLASH 1.11.2, Device:STM32Cube HAL:GPIO 1.11.2, Device:STM32Cube HAL:RCC 1.11.2, Device:Startup 1.11.2
